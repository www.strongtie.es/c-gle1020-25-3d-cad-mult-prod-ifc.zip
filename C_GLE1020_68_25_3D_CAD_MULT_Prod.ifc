Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:24:24
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:24:24 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{AF8AE5BC-030B-4DB3-821F-CBAEC4D99F70}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:24:24 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:24:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:24:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Normal Holes\RFA 3D\GLE1020_68_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Line Pattern: -3000010; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GLE1020_68_25, GLE1020_68_25:GLE1020_68_25:187311
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00803081 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE1020/68/2.5
Identity Data - OmniClass Number: 23.20.40.11.24.14; Description: Joist hanger; Name: GLE1020/68/2.5; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Title: Wood Connectors; Manufacturer: Simpson Strong-Tie; Model ID: 0018727601901072359436782674481097068920; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; ObjectType: GLE1020/68/2.5; Model: GLE1020/68/2.5; UniClass Number: Pr_20_29_31_44; URL: www.strongtie.eu
General - Density: 1.8; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE1020/68/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
