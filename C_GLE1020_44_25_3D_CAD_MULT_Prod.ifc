Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:24:14
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:24:14 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{73933F5F-539F-4BDF-B8B3-9AF02DF2F918}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:24:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:24:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:24:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Normal Holes\RFA 3D\GLE1020_44_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010; Symbol at End 2 Default: yes; Line Weight: 1
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: GLE1020_44_25, GLE1020_44_25:GLE1020_44_25:179775
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00803081 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE1020/44/2.5
Identity Data - Name: GLE1020/44/2.5; UniClass Number: Pr_20_29_31_44; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; Manufacturer: Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GLE1020/44/2.5; URL: www.strongtie.eu; ObjectType: GLE1020/44/2.5; OmniClass Title: Wood Connectors; Description: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Model ID: 0018727601901072359436782674481097068920; UniClass Title: Joist hangers; OmniClass Number: 23.20.40.11.24.14
General - Density: 1.8; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GLE1020/44/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
