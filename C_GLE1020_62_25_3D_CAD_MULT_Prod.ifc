Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:24:21
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:24:21 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{0A85A66B-DB60-4127-9463-F76C9156F27C}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:24:21 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:24:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:24:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Normal Holes\RFA 3D\GLE1020_62_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes; Color: 0

# IfcBuildingElementProxy: GLE1020_62_25, GLE1020_62_25:GLE1020_62_25:185427
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00803081 ft3
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE1020/62/2.5
Materials and Finishes - Product Material: Galvanised
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.8; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE1020/62/2.5
Identity Data - URL: www.strongtie.eu; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; Name: GLE1020/62/2.5; Model: GLE1020/62/2.5; Product Type: Joist hanger; Description: Joist hanger; Model ID: 0018727601901072359436782674481097068920; OmniClass Title: Wood Connectors; Manufacturer: Simpson Strong-Tie; Copyright: ©Simpson Strong-Tie; ObjectType: GLE1020/62/2.5
